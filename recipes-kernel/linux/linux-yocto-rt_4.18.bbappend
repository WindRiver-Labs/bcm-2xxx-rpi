#
# Copyright (C) 2018 Wind River Systems, Inc.
#

require linux-yocto-bcm-2xxx-rpi.inc

KBRANCH_bcm-2xxx-rpi = "v4.18/standard/preempt-rt/${KMACHINE}"
