require linux-windriver-bcm-2xxx-rpi.inc
