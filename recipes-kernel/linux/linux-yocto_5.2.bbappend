require linux-yocto-bcm-2xxx-rpi.inc

KBRANCH_rpi = "v5.2/standard/bcm-2xxx-rpi"

LINUX_VERSION_rpi ?= "5.2.x"
