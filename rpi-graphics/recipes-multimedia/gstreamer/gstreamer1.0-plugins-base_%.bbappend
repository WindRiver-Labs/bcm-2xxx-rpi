GSTREAM_PLUGINS_INC_WRLINUX = ""
GSTREAM_PLUGINS_INC_WRLINUX_osv-wrlinux = "gstreamer1.0-plugins-base_rpi.inc"
require ${GSTREAM_PLUGINS_INC_WRLINUX}
