UBOOT_MACHINE_rpi = "rpi_3_config"
